# Keil uVision project ano.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ano
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c include: .\SRC\applications;.\SRC\dbus;.\SRC\drivers;.\SRC\fc_general;.\SRC\fc_specific;.\SRC\fc_specific;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Libraries\CMSIS\Include;.\Libraries\CMSIS\ST\STM32F4xx\Include;.\Libraries\USBStack\INC;.\Libraries;.\Libraries\VL53L0X\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ./SRC/applications/: Ano_DT.c Ano_OF.c Ano_Parameter.c Ano_RC.c Ano_Scheduler.c Ano_USB.c BSP_Init.c main.c stm32f4xx_it.c usb_config.c
  group fc_general
    ./SRC/fc_general/: Ano_FcData.c Ano_Filter.c Ano_Imu.c Ano_Math.c Ano_MotionCal.c Ano_Navigate.c Ano_Pid.c
  group fc_specific
    ./SRC/fc_specific/: Ano_AltCtrl.c Ano_AttCtrl.c Ano_FlightCtrl.c Ano_FlightDataCal.c Ano_LocCtrl.c Ano_MagProcess.c Ano_MotorCtrl.c Ano_Power.c
  group dbus
    ./SRC/dbus/: dbus.c
  group drivers
    ./SRC/drivers/: Drv_adc.c Drv_ak8975.c Drv_gps.c Drv_i2c_soft.c Drv_icm20602.c Drv_led.c Drv_pwm_in.c Drv_pwm_out.c Drv_spi.c Drv_spl06.c Drv_time.c Drv_usart.c Drv_vl53l0x.c Drv_w25qxx.c usbd_STM32F4xx_FS.c
  group Libraries
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ./Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
    ./Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group USBStack
    ./Libraries/USBStack/SRC/: usbd_core.c usbd_core_hid.c usbd_hid.c
  group VL53L0X
    ./Libraries/VL53L0X/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_i2c.c vl53l0x_platform.c
